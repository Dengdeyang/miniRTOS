# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  AfterMake: fromelf -c -o "$L@L.lst" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\core;.\HAL\Inc;.\System;.\User\Inc;.\miniRTOS\Driver\Inc;.\miniRTOS\Kernel\Inc;.\miniRTOS\Memory\Inc;.\miniRTOS\Port\Inc;.\miniRTOS\Service\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/core/: core_cm3.c core_cm3.h
    ./CMSIS/Startup/: startup_stm32f10x_ld.s
  group HAL
    ./HAL/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h led.c uart.c
  group DOC
    ./DOC/: readme.txt miniRTOS简介.md
  group miniRTOS_Src
    ./miniRTOS/Kernel/Src/: event.c kernel.c list.c semaphore.c soft_timer.c
    ./miniRTOS/Memory/Src/: heap.c
    ./miniRTOS/Service/Src/: crc.c mini_libc.c
    ./miniRTOS/Driver/Src/: device.c
  group miniRTOS_Port
    ./miniRTOS/Port/Src/: miniRTOSport.c
    ./miniRTOS/Port/Inc/: miniRTOSconfig.h miniRTOSport.h
    ./miniRTOS/Port/Src/ARMCC/: miniRTOSswitch.s
target debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: VECT_TAB_SRAM
  c include: .\CMSIS\core;.\HAL\Inc;.\System;.\User\Inc;.\Objects;.\Listings
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
